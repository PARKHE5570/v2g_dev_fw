# IAR project JC-9V31-60-FT.ewp, settings and files
configuration EVSIS_60kW_DC_BPT (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105VC ST STM32F105VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCIncludePath2: ..\; ..\..\..\BSP\inc; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: JC-9A31-30-CU07_V108_240423.bin
  ILINK.IlinkOutputFile: JC-9642-300-012.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: self_test.h
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./: startup_stm32f105xc.s
  group User
    ../: Board_Pin_Config.h ctype.h digital_io.c digital_io.h fault_check.c fault_check.h FirmwareUpdate.c FirmwareUpdate.h HMI_modbus.c HMI_modbus.h Imd_communication.c Imd_communication.h INFY_V2G.c INFY_V2G.h main.c main.h PLC_3_0.c PLC_3_0.h pt1000.c pt1000.h self_check.c self_check.h sequence.c sequence.h sim200_can_sched.c sim200_can_sched.h sim200_port.c sim200_protocol.c sim200_protocol.h SIM_100.c SIM_100.h stm32f105_init.c stm32f105_init.h stm32f10x_it.c Terminal.c Terminal.h UART.c UART.h
