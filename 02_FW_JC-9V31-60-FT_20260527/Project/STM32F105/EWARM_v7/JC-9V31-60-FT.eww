<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\JC-9V31-60-FT.ewp</path>
    </project>
    <batchBuild />
</workspace>
